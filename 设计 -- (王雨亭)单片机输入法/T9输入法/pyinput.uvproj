# Keil uVision project pyinput.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pyinput +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\anjian;.\12864
  group Source Group 1
    ./: main.c pyinput.c
    ./anjian/: key.c
    ./12864/: lcd12864.c
