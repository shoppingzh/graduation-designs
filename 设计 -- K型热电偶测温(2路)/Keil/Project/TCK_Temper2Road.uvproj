# Keil uVision project TCK_Temper2Road.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: TCK_Temper2Road +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: tck_max6675.c lcd1602.c timer.c uart.c
