# Keil uVision project FPM10A_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: FPM10A_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User,..\Hardware
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: lcd1602.c uart_syn.c fpm10a.c
