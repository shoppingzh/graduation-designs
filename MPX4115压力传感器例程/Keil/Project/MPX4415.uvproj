# Keil uVision project MPX4415.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MPX4415 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User,..\Hardware
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: uart.c adc.c
