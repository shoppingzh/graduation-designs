# Keil uVision project DS18B20_Cascade.uvproj, settings and files
target DS18B20_CASCADE (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS18B20_Cascade +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Hardware
  group USER
    ../User/: main.c
  group HARDWARE
    ../Hardware/: ds18b20.c uart.c
