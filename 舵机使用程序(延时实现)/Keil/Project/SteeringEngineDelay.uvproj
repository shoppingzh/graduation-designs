# Keil uVision project SteeringEngineDelay.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: SteeringEngineDelay +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group User
    ../User/: main.c
