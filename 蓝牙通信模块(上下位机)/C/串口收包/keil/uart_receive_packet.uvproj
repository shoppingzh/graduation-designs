# Keil uVision project uart_receive_packet.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: uart_receive_packet +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\HARDWARE
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: uart.c uart_support.c
