# Keil uVision project temper.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: temper +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Hardware
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: ds18b20.c uart.c lcd1602.c
