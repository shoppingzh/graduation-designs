# Keil uVision project AutoLocker.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AutoLocker +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User,..\Hardware
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: fpm10a.c lcd12864.c uart_syn.c
