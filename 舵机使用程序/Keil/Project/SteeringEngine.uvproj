# Keil uVision project SteeringEngine.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: SteeringEngine +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User
  group User
    ../User/: main.c
