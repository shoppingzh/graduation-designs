# Keil uVision project TemperatureColl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TemperatureColl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: uart.c tck_max6675.c adc.c ds18b20.c
