# Keil uVision project OverloadDetection.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: OverloadDetection +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Uesr,..\Hardware
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: adc.c lcd1602.c
