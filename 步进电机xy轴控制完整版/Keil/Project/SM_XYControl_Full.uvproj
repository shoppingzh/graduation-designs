# Keil uVision project SM_XYControl_Full.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: SM_XYControl_Full +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: timer.c sm.c
