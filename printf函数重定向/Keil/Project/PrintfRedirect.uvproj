# Keil uVision project PrintfRedirect.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: PrintfRedirect +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User;..\System
  group User
    ../User/: main.c
  group System
    ../System/: printer.c
    ../Hardware/: uart.c
