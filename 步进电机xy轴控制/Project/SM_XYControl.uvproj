# Keil uVision project SM_XYControl.uvproj, settings and files
target SM_XYControl (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: SM_XYControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\User
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/: sm.c timer.c
